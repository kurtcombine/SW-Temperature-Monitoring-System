# Keil uVision project proj.uvprojx, settings and files
target Target_1 (6110000::V6.11::.\ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: proj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Libraries\LCP1768_StdPeriph_Driver\include;..\Libraries\LCP1768_StdPeriph_Driver\source;..\..\projekt-z-symulacja\global
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c at24xx.h
    ../Libraries/LCP1768_StdPeriph_Driver/source/: lpc17xx_clkpwr.c lpc17xx_i2c.c lpc17xx_pinsel.c
software components: CMSIS Driver:I2C:Custom 1.0.0, CMSIS:CORE 6.1.0, Board Support:LED 1.0.0, CMSIS Driver:I2C 2.6.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
