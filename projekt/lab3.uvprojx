# Keil uVision project lab3.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: D:\systemy wbudowane\biblioteki\gfx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c
    ../biblioteki/1wire/: onewire_DS18B20.h
    ../biblioteki/gfx/: asciiLib.c asciiLib.h LCD_ILI9325.c LCD_ILI9325.h lcdDrawing.h lcdTouch.h Open1768_LCD.c Open1768_LCD.h TP_Open1768.c TP_Open1768.h
software components: CMSIS:CORE 5.2.0, Board Support:LED 1.0.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
