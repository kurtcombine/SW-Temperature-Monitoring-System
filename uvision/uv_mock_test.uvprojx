# Keil uVision project uv_mock_test.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uv_mock_test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..;..\ds18b20;..\global;..\lcd;..\mem;..\embedded_libraries
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../: main.c
    ../mem/: mem.c
    ../lcd/: asciiLib.c lcd.c lcd_mock.c
    ../global/: global_embed.c global_mock.c
    ../ds18b20/: onewire_DS18B20.c onewire_DS18B20_mock.c
    ../embedded_libraries/: Open1768_LCD.c LCD_ILI9325.c
software components: CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, Board Support:LED 1.0.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
